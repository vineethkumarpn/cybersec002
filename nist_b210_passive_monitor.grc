options:
  parameters:
    category: NIST Wireless Monitoring
    description: Receive-only B210 spectrum and energy monitor
    gen_cmake: 'Off'
    generate_options: qt_gui
    id: nist_b210_passive_monitor
    output_language: python
    title: NIST B210 Passive Monitor (Receive Only)
  states: {}

blocks:
- name: center_freq
  id: variable_qtgui_range
  parameters:
    label: Center frequency (Hz)
    min_len: '300'
    start: '70000000'
    step: '1000000'
    stop: '6000000000'
    value: '2412000000'
    widget: eng_slider
  states: {}
- name: sample_rate
  id: variable_qtgui_range
  parameters:
    label: Sample rate (samples/s)
    min_len: '250'
    start: '1000000'
    step: '100000'
    stop: '2000000'
    value: '1000000'
    widget: eng_slider
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    label: RX gain (dB)
    min_len: '250'
    start: '0'
    step: '1'
    stop: '76'
    value: '20'
  states: {}
- name: antenna_port
  id: variable_qtgui_chooser
  parameters:
    label: RX antenna
    labels: '["RX2", "TX/RX", "RX1"]'
    num_opts: '0'
    options: '["RX2", "TX/RX", "RX1"]'
    type: string
    value: '"RX2"'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: antenna_port
    center_freq0: center_freq
    clock_rate: '0.0'
    dev_addr: '"type=b200"'
    dev_args: '""'
    gain0: rx_gain
    num_mboards: '0'
    rx_agc0: Disabled
    samp_rate: sample_rate
    sync: none
    type: fc32
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    fc: center_freq
    fftsize: '2048'
    grid: 'True'
    label: '"Relative power"'
    label1: '"B210 input"'
    name: '"Received spectrum"'
    ymin: '-120'
    bw: sample_rate
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    grid: 'True'
    name: '"Received power (linear)"'
    size: '1024'
    srate: sample_rate
    type: float
    ylabel: '"Power"'
    yunit: '"linear"'
    ymin: '0'
  states: {}

connections:
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_complex_to_mag_squared_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: v3.10.12.0
